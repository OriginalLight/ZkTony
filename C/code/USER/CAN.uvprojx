# Keil uVision project CAN.uvprojx, settings and files
target CAN (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,DEBUG_ENABLE_SEMIHOST
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\CAN;..\HARDWARE\24CXX;..\HARDWARE\EXTI;..\HARDWARE\IIC;..\HARDWARE\PWM;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\W25QXX;..\HARDWARE\Moto;..\USMART;..\HARDWARE\Stringdeal;..\HARDWARE\Device;..\HARDWARE\DAC;..\HARDWARE\ADC;..\HARDWARE\Dacai;..\RTT;..\HARDWARE\NMOS;..\HARDWARE\CRC16;..\STM32F4xx_HAL_Driver\Inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/Moto/: moto.c
    ../HARDWARE/Dacai/: hmi_driver.c cmd_queue.c string_deal.c cmd_process.c
    ../HARDWARE/IIC/: bsp_i2c_gpio.c bsp_eeprom_24xx.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/NMOS/: nmos.c nmos.h
    ../HARDWARE/CRC16/: CRC16.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dac.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT.h SEGGER_RTT_Conf.h
